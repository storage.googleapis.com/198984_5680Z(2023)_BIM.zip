Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-02-07T17:04:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Feb 07 17:04:00 2024 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\619336c7-72e8-46ce-b46f-fec3da8e1044\f203868a-9293-4536-95af-2c28cd405e22\ifc * Database version: 5507 * Database creation date: Wed Feb 07 17:03:37 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Feb 07 17:03:38 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Feb 07 17:03:38 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 5680Z Oras Clinica, 5680Z(2023):5680Z Oras Clinica:427295
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - NominalDepth: 190.906 mm; NominalHeight: 162.33 mm; NominalWidth: 195.515 mm
Type - Electrical - Bluetooth: 5.x (D060576); Operating Voltage: 0 V; Protection Class: IP 55
Type - General - Author: BIMStone; BIMObjectName: 5680Z(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 17/01/2024
Type - Green Building Properties - EAN Number: 6414150103728; EMC Directive: Radio Equipment Directive 2014/53/EU , Low Voltage Directive 2014/35/EU , EMC Directive 2014/30/EU , RoHS Directive 2011/65/EU; Sales Package dimensions (LxWxH): 278 x 218 x 202; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/5680Z; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; URL WEEE: http://static.oras.com/WEEE/5680Z
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/5680Z; 3D View: https://static.oras.com/AR/5680Z; Catalog Drawing URL: http://static.oras.com/catdrw/5680Z; Dimension Drawing URL: http://static.oras.com/dimdrw/5680Z; FDV Document URL: http://www.oras.com/datasheet/5680Z/en/fdv; Group: Sales item; Installation and Maintenance Guide URL: http://static.oras.com/manual/5680Z; Interactive AR View URL: https://static.oras.com/AR/5680Z; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark;Poland; Mobile Product Information URL: http://mpi.oras.com/5680Z; Model: 5680Z Oras Clinica; Name_en: 5680Z Oras Clinica; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 5680Z; Product Family: Digital+ Single-lever;Self-powered;Bluetooth®;Lead free; Product Image URL: http://static.oras.com/image/5680Z; Product URL: http://static.oras.com/5680Z; Short Marketing: This faucet is designed for Health care usage. With its low lead water ways and a well designed body that is easy to clean while the long lever makes it easy and intuitive to operate. With our latest technology it is possible to connect this faucet to the Digital water management service. The online service helps monitoring of the usage to prevent stagnation and to follow-up the temperatures in the piping. Measuring technology inside the faucet body is self-powered by water, no batteries needed. Clever design with a world of information inside.; Technical DataSheet URL: http://www.oras.com/datasheet/5680Z/en; Type Name: 5680Z Oras Clinica; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Composite; Connection: Eccentric coupling(s); Installation Type: Wall mounted; Lever Handle: Pin shape; Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control; Surface treatment: Chrome
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 5680Z(2023); Features: Washbasin faucet; Finish: Polished; Grade: n/a; ModelNumber: n/a; ModelReference: 5680Z; Name: 5680Z Oras Clinica; ReplacementCost: n/a; Shape: Sculptured; Size: 196x190x165 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 5680Z Oras Clinica; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 5680Z; Manufacturer: Oras
Pset_ProductRequirements - Name: 5680Z Oras Clinica; Category: Plumbing Fixtures
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.102055 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00607131 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 5680Z(2023): 5680Z Oras Clinica; Family and Type: 5680Z(2023): 5680Z Oras Clinica; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 5680Z(2023): 5680Z Oras Clinica; Type Id: 5680Z(2023): 5680Z Oras Clinica; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
